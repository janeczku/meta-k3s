require k3s-bin-arch.inc

K3S_VERSION="0.6.1"
PR = "${INC_PR}.0"
PV = "${K3S_VERSION}-${PR}"

# LIC_FILES_CHKSUM = "file://LICENSE;md5=2ee41112a44fe7014dce33e26468ba93"
